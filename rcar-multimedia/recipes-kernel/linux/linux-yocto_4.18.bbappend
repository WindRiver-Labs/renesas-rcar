FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append_h3ulcb = " file://multimedia.cfg"
SRC_URI_append_m3ulcb = " file://multimedia.cfg"
