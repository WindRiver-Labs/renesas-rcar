require linux-yocto-renesas-rcar.inc

KBRANCH_rcar-gen3 = "v4.18/standard/renesas/rcar-3.9.4/renesas-rcar"
