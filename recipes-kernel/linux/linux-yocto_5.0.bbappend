require linux-yocto-renesas-rcar.inc

KBRANCH_rcar-gen3 = "v5.0/standard/base"
