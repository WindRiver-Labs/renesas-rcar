require linux-yocto-renesas-rcar.inc

KBRANCH_rcar-gen3 = "v5.2/standard/base"

LINUX_VERSION_rcar-gen3 ?= "5.2.x"
