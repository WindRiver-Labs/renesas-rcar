# Append path for renesas-rcar bsp include xorg.conf 
FILESEXTRAPATHS_prepend_rcar-gen3 := "${THISDIR}/${PN}:"
