UBOOT_CONFIG_remove_renesas-rcar-h3 = "h3ulcb-4x2g"
